# Keil uVision project ULTRA_8051_BoartTest.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RD2 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: ULTRA_8051_BoartTest +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: adc.c adc.h delay.c delay.h eeprom.c eeprom.h gpio.c gpio.h i2c.c i2c.h keypad.c keypad.h lcd.c lcd.h main.c rtc.c rtc.h stdutils.h uart.c uart.h
