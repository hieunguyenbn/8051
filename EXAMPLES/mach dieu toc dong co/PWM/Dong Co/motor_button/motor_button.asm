ORG 00H
LJMP MAIN
ORG 30H
MAIN:
	CLR P3.6
	CLR P3.7
	JNB P0.0, START
	JNB P0.2, UP
	JNB P0.4, DOWN
	JNB P0.7, STOP
	JMP MAIN
;---------------------------------------------------------------------------------------------------------------------------------------------
	START:
	   	SETB P3.6
		CLR P3.7
		MOV R6, #100
	HERE:
		CALL DELAY
		DJNZ R6, HERE
	RET
;---------------------------------------------------------------------------------------------------------------------------------
    UP:
		SETB P3.6
		CLR P3.7
		MOV R6, #300
	HERE1:
		CALL DELAY
		DJNZ R6, HERE1
	    CPL P3.6
		CPL P3.7
		MOV R7, #300
	HERE2:
		CALL DELAY
		DJNZ R7, HERE2

			
	RET
;----------------------------------------------------------------------------------------------------------------------------------------------
	
	DUNG:
	   CLR P3.6
	   CLR P3.7
	   MOV R5, #5
	   		CALL DELAY
	   		
	RET
;-----------------------------------------------------------------------------------------------------------------------------------------------
	DOWN:
	  	SETB P3.7
		CLR P3.6
		MOV R6, #200
	HERE3:
		CALL DELAY
		DJNZ R6, HERE3
		CPL P3.7
		CPL P3.6
	MOV R7, #200
	HERE4:
		CALL DELAY
		DJNZ R7, HERE4
	RET
;---------------------------------------------------------------------------------------------------------------------------------------------
	STOP:
	   CLR P3.6
	   SETB P3.7
	RET
;--------------------------------------------------------------------------------------------------------------------------------
	DELAY:
	   MOV TMOD, #01h
	   MOV R5, #20
	   TRE1S:
		   MOV TH0, #(-50000)
		   MOV TL0, #(-50000)
		   SETB TR0
		   JNB TF0, $
		   CLR TR0
		   CLR TF0
		   DJNZ R5, TRE1S
	RET

END