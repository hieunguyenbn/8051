ORG 00H
MAIN:

        CALL TAOXUNG
	JMP MAIN

   TAOXUNG:
	   	SETB P1.2
		SETB P1.3
	LAP:
		CALL DELAY250
		CPL P1.3
		CALL DELAY250
		CPL P1.3
		CALL DELAY250
		CPL P1.3
		CALL DELAY250
		CPL P1.3
     	        CPL P1.2
   JMP LAP

	RET

   DELAY250:
	   MOV TMOD, #01H
	   MOV TH0, #HIGH(-250)
	   MOV TL0, #LOW(-250)
	   SETB TR0
	   JNB TF0, $
		CLR TR0
		CLR TF0
	RET 
END
