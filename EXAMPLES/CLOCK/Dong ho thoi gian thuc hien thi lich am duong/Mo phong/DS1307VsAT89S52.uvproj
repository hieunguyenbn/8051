# Keil uVision project DS1307VsAT89S52.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: DS1307VsAT89S52 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: source.c
