# Keil uVision project ADC_single_slope.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: ADC_single_slope +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: ADC_single_slope.asm
