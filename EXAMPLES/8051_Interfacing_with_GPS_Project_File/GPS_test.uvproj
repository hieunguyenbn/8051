# Keil uVision project GPS_test.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: GPS_test +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: GPS_test.c LCD_20x4_C_file.c LCD_20x4_H_file.h USART_Interrupt.c USART_Interrupt.h
