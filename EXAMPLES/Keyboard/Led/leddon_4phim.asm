ORG 00H
MOV P1,#00H
MOV A,#00000001B
KEY1:
    JNB P0.2,KEY10
	JMP KEY2
	KEY10:
	CALL DELAY
	RR A
	MOV P1,A
	CALL DELAY
	JMP KEY1
KEY2:
    JNB P0.4,KEY20
	JMP KEY3
	KEY20:
	CALL DELAY
	RL A
	MOV P1,A
	CALL DELAY
	JMP KEY2
KEY3:
    JNB P0.0,KEY30
	JMP KEY4
	KEY30:
		JNB P0.2,KEY10
		JNB P0.4,KEY20
	    JNB P0.7,KEY40
		RR A
		MOV P1,A
		CALL DELAY
		JMP KEY30
KEY4:
    JNB P0.7,KEY40
	JMP KEY1
	KEY40:
		JNB P0.2,KEY10
		JNB P0.4,KEY20
	    JNB P0.0,KEY30
		RL A
		MOV P1,A
		CALL DELAY
		JMP KEY40
DELAY:
	MOV R1,200
	LAP:
	MOV R2,#200
	LAP1:
	NOP
	NOP
	DJNZ R2,LAP1
	DJNZ R1,LAP
	RET
END
