# Keil uVision project interrupt_timer1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: interrupt_1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: interrupt_timer.c
    ../../LIBRARY/: delay.c
