# Keil uVision project Dong ho led 7 doan.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: Dong ho led 7 doan +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Dong ho led 7 doan.c
