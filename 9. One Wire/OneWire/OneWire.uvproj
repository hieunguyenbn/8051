# Keil uVision project OneWire.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: OneWire +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: OneWire.c
    ../../LIBRARY/: delay.c ds18b20.c lcd4.c
