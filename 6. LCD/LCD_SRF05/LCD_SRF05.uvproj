# Keil uVision project LCD_SRF05.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: LCD_SRF05 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../../LIBRARY/: delay.c
    ./: LCD_SRF05_2.c
