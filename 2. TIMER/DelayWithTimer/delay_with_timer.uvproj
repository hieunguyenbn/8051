# Keil uVision project delay_with_timer.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: delay_with_timer +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: timer_mode_01.c
